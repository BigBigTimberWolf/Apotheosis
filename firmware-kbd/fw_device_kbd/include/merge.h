// ============================================================================
// merge.h —— 真实输入 + 上位机注入 的合并逻辑
//
// 【职责】
//   把两个来源合成一路 HID 报文发给被控机:
//     来源A: 真键盘/真鼠标的原始报文 (从右板经 Serial1 来)
//     来源B: 上位机注入命令      (从 CH343 来)
//
// 【合并规则 (按你的要求)】
//   键盘:
//     最终键码 = 真实键码 ∪ 注入键码
//     修饰键   = 真实修饰 ∪ 注入修饰
//     GHOST 开启时: 真实部分【整个丢弃】, 只发注入部分
//
//   鼠标:
//     位移     = 真实位移 + 注入位移   (相加, 因为位移是相对的)
//     按键     = 真实按键 ∪ 注入按键   (或的关系, 绝对态)
//     滚轮     = 真实 + 注入
//
// 【为什么要合并而不是二选一】
//   你要求: "上位机发出的命令 + 我的真实输入能够尽量都完美执行"
//   所以两者都要保留, 用 OR/加法合成, 而不是互相覆盖。
//
// 【时序】
//   报文按固定周期送出 (见 REPORT_INTERVAL_US), 每个周期取一次快照发送。
//   这样:
//     - 真实输入和注入都不会丢
//     - 发送频率稳定, 不随输入抖动
// ============================================================================

#ifndef MERGE_H
#define MERGE_H

#include <stdint.h>
#include <string.h>

// ---------------------------------------------------------------------------
// 键盘状态: 标准 boot keyboard 布局
//   byte0 = 修饰键位图 (bit0 LCtrl ... bit7 RGUI)
//   byte1 = 保留
//   byte2..7 = 6 个键码
// ---------------------------------------------------------------------------
struct KbdState {
    uint8_t mod;          // 修饰键位图
    uint8_t keys[6];      // 6 个键码 (0 = 空)

    void clear() { mod = 0; memset(keys, 0, sizeof(keys)); }

    // 合并: 修饰键取并集, 键码去重后并集
    void mergeFrom(const KbdState &o) {
        mod |= o.mod;
        for (int i = 0; i < 6; ++i) {
            if (o.keys[i] == 0) continue;
            // 已存在则跳过
            bool dup = false;
            for (int j = 0; j < 6; ++j) if (keys[j] == o.keys[i]) { dup = true; break; }
            if (dup) continue;
            // 找空位
            for (int j = 0; j < 6; ++j) if (keys[j] == 0) { keys[j] = o.keys[i]; break; }
        }
    }
};

// ---------------------------------------------------------------------------
// 鼠标状态: 标准 5 键 + 3 轴
// ---------------------------------------------------------------------------
struct MouseState {
    uint8_t buttons;      // bit0 L, bit1 R, bit2 M, bit3 S1, bit4 S2
    int16_t dx, dy;       // 相对位移 (累加)
    int8_t  wheel;        // 滚轮 (累加)

    void clear() { buttons = 0; dx = dy = 0; wheel = 0; }
    void clearDelta() { dx = dy = 0; wheel = 0; }
};

#endif // MERGE_H
